# Keil uVision project UCOSII-3.uvprojx, settings and files
target LEG_POWER (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,  ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\circle;..\HARDWARE\IIC;..\HARDWARE\demo;..\HARDWARE\NAV2;..\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../HARDWARE/IIC/: ucos_task.c include.h
    ./: main.c
    ../UCOSII/CONFIG/: os_cfg.h
  group SYSTEM
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_rng.c stm32f4xx_dac.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group HARDWARE
    ../HARDWARE/IIC/: flash.c led_fc.c pwm_out.c time.c dma.c rng.c bat.c beep.c watch_dog.c spi.c nrf.c pressure.c flash_w25.c iic_vl53.c vl6180x_i2c.c
  group COMMUNICATION
    ../HARDWARE/IIC/: usart_fc.c rc_mine.c sbus_oldx.lib
  group MEMS
    ../HARDWARE/IIC/: mems.c icm20602.c imu.c ms5611.c cycle_cal_oldx.lib
  group CONTROL
    ../HARDWARE/IIC/: vmc_demo.c vmc_sdk.c eso.c F407_FC.lib
  group MATH&FUSHION
    ../HARDWARE/IIC/: fliter.c my_math.c
    ../DSP/: arm_cortexM4lf_math.lib
  group POSE_FUSHION
    ../HARDWARE/NAV2/: nav2.c baro_fushion.c ekf_pos.c inv.c mpower.c rt_nonfinite.c rtGetInf.c rtGetNaN.c baro_kf.c
